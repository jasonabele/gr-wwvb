<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>wwvb_demod_recording</value></param>
<param><key>title</key><value>WWVB Demodulate Recording</value></param>
<param><key>author</key><value>Jason Abele</value></param>
<param><key>description</key><value>Demonstrate WWVB Demodulation using recorded WWVB data from: http://www.jks.com/wwvb/wwvb.html</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>channel*bw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>15625</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>44100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>final_samp_rate</value></param>
<param><key>value</key><value>10.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>costas_freq</value></param>
<param><key>value</key><value>center_freq + freq_est_probe*bw/2.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rs_taps</value></param>
<param><key>value</key><value>firdes.low_pass(nfilters, nfilters, (freq-bw/2.0)/(samp_rate/2.0), (freq+bw/2.0)/(samp_rate/2.0))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channels</value></param>
<param><key>value</key><value>42</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilters</value></param>
<param><key>value</key><value>channels</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tagFrame</value></param>
<param><key>value</key><value>gr.tag_utils.python_to_tag((59, pmt.intern('frame'), pmt.intern('S'), pmt.intern("src")))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tagPosition</value></param>
<param><key>value</key><value>gr.tag_utils.python_to_tag((9, pmt.intern('Position'), pmt.intern('P'), pmt.intern("src")))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>samp_rate/channels</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>alpha</key><value>0.1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>probe_avg_mag_sqrd</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>alpha</key><value>0.0001</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>channel</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>value</key><value>15</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>channels</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>freq_est_label</value></param>
<param><key>label</key><value>Frequency Estimate</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>costas_freq</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_est_probe</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>freq_estimate</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>avg_mag_probe</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>probe_avg_mag_sqrd</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>avg_mag_sqrd</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Average Mag^2</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>avg_mag_probe</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate*realtime_speedup</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/jason/Projects/gnuradio/wwvb/ant.wide.5min.15.625.kHz.44.1k.24b.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_pmt</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>bits_per_chunk</key><value>10</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>120</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>(samp_rate/channels)*10</value></param>
<param><key>srate</key><value>samp_rate/channels</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>256</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>center_freq</value></param>
<param><key>bw</key><value>samp_rate/channels</value></param>
<param><key>ymin</key><value>-100</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>10*samp_rate/channels</value></param>
<param><key>srate</key><value>samp_rate/channels</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_1</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>pfb_decimator_ccf</key>
<param><key>id</key><value>pfb_decimator_ccf_0</value></param>
<param><key>decim</key><value>channels</value></param>
<param><key>taps</key><value>rs_taps</value></param>
<param><key>channel</key><value>channel</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>0.0614</value></param>
<param><key>order</key><value>2</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>freq_estimate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>256</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate/channels</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>ymin</key><value>-100</value></param>
<param><key>showports</key><value>True</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>rrate</key><value>final_samp_rate/(samp_rate/channels)</value></param>
<param><key>taps</key><value>(1.0)</value></param>
<param><key>nfilts</key><value>int(final_samp_rate)</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>int(final_samp_rate)*10</value></param>
<param><key>srate</key><value>final_samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ymin</key><value>-1.0</value></param>
<param><key>ymax</key><value>1.0</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-2.0</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-1</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0</value></param>
<param><key>access_code</key><value>00000000110000000011</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>tagname</key><value>tagFrame</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_bb</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0</value></param>
<param><key>access_code</key><value>0000000011</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>tagname</key><value>tagPosition</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0_0</value></param>
</block>
<block>
<key>blocks_uchar_to_float</key>
<param><key>id</key><value>blocks_uchar_to_float_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>size</key><value>int(final_samp_rate)*120</value></param>
<param><key>srate</key><value>final_samp_rate</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>ymin</key><value>0</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>realtime_speedup</value></param>
<param><key>label</key><value>Realtime Speedup</value></param>
<param><key>value</key><value>10</value></param>
<param><key>start</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pfb_decimator_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>probe_avg_mag_sqrd</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_uchar_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0</source_block_id><sink_block_id>blocks_uchar_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>freq_estimate</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>blocks_uchar_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_uchar_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_decimator_ccf_0</source_block_id><sink_block_id>blocks_complex_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
